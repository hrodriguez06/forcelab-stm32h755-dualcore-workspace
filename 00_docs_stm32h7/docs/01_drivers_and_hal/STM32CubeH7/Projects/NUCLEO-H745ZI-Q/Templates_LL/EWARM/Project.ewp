# IAR project Project.ewp, settings and files
configuration STM32H745I_Nucleo_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745ZI_CM7 ST STM32H745ZI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_FULL_LL_DRIVER; STM32H745xx; CORE_CM7
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\Common\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H745I_Nucleo_CM7.hex
  ILINK.IlinkOutputFile: STM32H743ZI-Nucleo.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H745I_Nucleo_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745ZI_CM4 ST STM32H745ZI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_FULL_LL_DRIVER; STM32H745xx; CORE_CM4
  ICCARM.CCIncludePath2: ..\CM4\Inc; ..\Common\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  OBJCOPY.OOCOutputFile: STM32H745I_Nucleo_CM4.hex
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32h745xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c
